// Native oracle: original physical Controller, TopIR, Robot I2C and wheel model.
// Each line is input (time, command, absolute counts, ADCs) followed by the
// observed firmware output. Input values are generated by this build only;
// browser code must replay those very same inputs without deciding the trace.
#include "Arduino.h"
#include "Controller.h"
#include <cassert>
#include <iostream>
#include <iomanip>
#include <cmath>
#include <string>
using namespace std;
int main(){
 Robot_c r; TopIR_c ir; Controller_c c;
 r.initialise(); ir.initialise(); hw::ms=0; c.initialise(r,ir);
 auto row=[&](char cmd,char kind){
   auto p=c.odometry().pose;
   cout<<kind<<'\t'<<hw::ms<<'\t'<<cmd<<'\t'<<hw::leftCount<<'\t'<<hw::rightCount<<'\t'<<hw::adc[0]<<'\t'<<hw::adc[1]<<'\t'<<hw::adc[4]
       <<'\t'<<c.modeName()<<'\t'<<c.phaseName()<<'\t'<<hw::left<<'\t'<<hw::right<<'\t'<<c.calibrated()
       <<'\t'<<c.leftThreshold()<<'\t'<<c.rightThreshold()<<'\t'<<setprecision(10)<<p.x<<'\t'<<p.y<<'\t'<<p.theta
       <<'\t'<<c.note()<<'\n';};
 auto cmd=[&](char key){c.command(key,r,ir);row(key,'c');};
 auto tick=[&](int d=10){hw::ms+=d;c.update(r,ir);row('-','t');};
 auto mode=[&](const string& s){return s==c.modeName();};
 row('-','i');cmd('E');assert(mode("ESCAPE")&&!c.calibrated());
 for(int i=0;i<10;i++)tick();
 assert(hw::left>0&&hw::right>0&&!c.calibrated());
 cmd('X');assert(mode("IDLE")&&hw::left==0&&hw::right==0);
 cmd('C');
 for(int i=0;i<5000&&mode("CALIBRATE");++i){
   if(hw::left>=8)hw::leftCount++;if(hw::right>=12)hw::rightCount++;tick();
 }
 assert(c.calibrated()&&c.leftThreshold()==8&&c.rightThreshold()==12);
 for(char action:{'T','L','S'}){
   cmd(action);bool completed=false;
   for(int i=0;i<1000;++i){
     hw::leftCount+=(hw::left>0?2:hw::left<0?-2:0);hw::rightCount+=(hw::right>0?2:hw::right<0?-2:0);
     tick();if(mode("IDLE")){completed=true;break;}
   }assert(completed);
 }
 cmd('E');
 float edge=-1;bool turned=false,weak=false,centre=false,cross=false;int i=0;
 for(;i<3000&&mode("ESCAPE");++i){
   string ph=c.phaseName(); const float x=c.odometry().pose.x;
   if(ph=="FOLLOW"&&edge<0)edge=x+55;float dx=x-edge;
   turned|=ph=="TURN_RIGHT";centre|=ph=="CENTRE";cross|=ph=="CROSS";
   if(turned||(edge>=0&&dx>=12)) hw::adc[4]=4095;
   else if(edge>=0&&dx>=6)hw::adc[4]=3670;
   else if(edge>=0&&dx>=0){hw::adc[4]=3550;weak=true;}
   else hw::adc[4]=3000;
   hw::leftCount+=(hw::left>0?2:hw::left<0?-2:0);hw::rightCount+=(hw::right>0?2:hw::right<0?-2:0);
   tick();
 }
 assert(turned&&weak&&centre&&cross&&mode("IDLE")&&string(c.note()).find("andidate")!=string::npos);
 // A low rear reading cannot abort escape. A front obstacle still starts a corner turn.
 cmd('E');
 hw::adc[1]=1900;hw::adc[4]=472;
 for(int i=0;i<12;i++)tick();
 assert(mode("ESCAPE")&&string(c.phaseName())=="TURN_LEFT"&&hw::left<0&&hw::right>0);
 // Operator stop remains available, even in the middle of the turn.
 cmd('X');assert(mode("IDLE")&&hw::left==0&&hw::right==0);
 // A suspicious right edge without a confirmed opening used to end the run.
 // Reproduce that decision boundary; the next firm wall should rearm a new search.
 hw::adc[1]=4095;hw::adc[4]=3000;
 for(int i=0;i<10;i++)tick();
 cmd('E');
 auto forwardTick=[&](){hw::leftCount+=2;hw::rightCount+=2;tick();};
 for(int i=0;i<130;i++)forwardTick();
 assert(mode("ESCAPE")&&string(c.phaseName())=="FOLLOW");
 hw::adc[4]=3550;
 for(int i=0;i<100 && string(c.phaseName())=="FOLLOW";i++)forwardTick();
 assert(mode("ESCAPE")&&string(c.phaseName())=="SEEK");
 hw::adc[4]=4095;
 for(int i=0;i<30;i++)forwardTick();
 assert(mode("ESCAPE")&&string(c.phaseName())=="SEEK");
 hw::adc[4]=3000;
 for(int i=0;i<40;i++)forwardTick();
 assert(mode("ESCAPE")&&string(c.phaseName())=="FOLLOW");
 cmd('X');assert(mode("IDLE"));
}
